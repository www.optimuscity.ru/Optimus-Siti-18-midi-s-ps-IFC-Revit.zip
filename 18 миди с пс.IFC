Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: 18 миди с пс.IFC
Time: 2025-11-26T10:53:23
Written by: SwIFC
Made in: SolidWorks 2020

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 18.stp[100]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[101]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[102]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[103]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[104]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[105]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[106]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[107]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[108]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[109]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[110]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[111]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[112]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[113]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[114]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[115]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[116]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[117]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[118]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[119]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[120]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[121]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[122]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[123]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[124]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[125]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[126]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[127]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[128]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[129]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[130]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[131]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[132]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[133]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[134]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[135]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[136]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[137]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[138]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[139]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[13]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[140]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[141]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[142]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[143]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[144]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[145]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[146]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[147]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[148]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[149]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[14]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[150]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[151]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[152]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[153]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[154]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[155]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[156]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[157]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[158]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[159]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[15]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[160]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[161]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[162]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[163]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[164]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[165]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[166]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[167]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[168]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[169]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[16]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[170]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[171]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[172]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[173]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[174]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[175]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[176]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[177]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[178]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[179]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[17]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[180]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[181]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[182]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[183]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[184]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[185]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[186]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[187]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[188]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[189]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[18]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[190]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[191]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[192]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[193]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[194]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[195]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[196]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[197]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[198]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[199]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[19]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[200]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[201]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[202]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[203]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[204]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[205]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[206]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[207]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[208]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[209]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[20]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[210]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[211]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[212]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[213]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[214]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[215]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[216]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[217]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[218]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[219]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[21]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[220]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[221]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[222]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[223]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[224]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[225]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[226]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[227]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[228]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[229]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[22]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[230]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[231]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[232]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[233]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[234]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[235]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[236]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[237]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[238]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[239]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[23]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[240]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[241]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[242]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[243]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[244]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[245]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[246]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[247]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[248]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[249]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[24]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[250]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[251]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[252]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[253]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[254]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[255]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[256]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[257]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[258]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[259]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[25]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[260]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[261]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[262]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[263]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[264]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[265]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[266]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[267]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[268]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[269]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[26]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[270]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[271]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[272]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[273]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[274]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[275]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[276]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[277]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[278]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[279]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[27]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[280]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[281]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[282]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[283]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[284]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[285]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[286]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[287]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[288]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[289]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[28]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[290]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[291]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[292]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[293]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[294]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[295]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[296]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[297]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[298]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[299]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[29]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[300]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[301]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[302]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[303]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[304]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[305]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[306]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[307]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[308]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[309]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[30]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[310]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[311]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[312]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[313]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[314]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[315]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[316]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[317]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[318]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[319]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[31]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[320]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[321]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[322]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[323]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[324]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[325]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[326]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[327]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[328]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[329]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[32]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[330]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[331]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[332]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[333]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[334]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[335]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[336]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[337]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[338]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[339]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[33]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[340]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[341]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[342]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[343]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[344]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[345]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[346]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[347]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[348]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[349]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[34]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[350]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[351]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[352]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[353]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[354]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[355]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[356]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[357]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[358]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[359]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[35]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[360]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[361]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[362]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[363]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[364]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[365]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[366]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[367]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[368]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[369]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[36]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[370]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[371]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[372]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[373]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[374]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[375]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[376]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[377]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[378]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[379]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[37]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[380]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[381]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[382]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[383]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[384]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[385]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[386]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[387]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[388]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[389]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[38]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[390]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[391]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[392]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[393]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[394]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[395]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[396]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[397]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[398]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[399]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[39]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[400]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[401]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[402]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[403]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[404]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[405]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[406]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[407]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[408]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[409]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[40]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[410]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[411]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[412]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[413]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[414]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[415]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[416]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[417]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[418]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[419]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[41]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[420]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[421]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[422]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[423]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[424]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[425]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[426]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[427]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[428]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[429]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[42]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[430]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[431]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[432]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[433]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[434]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[435]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[436]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[437]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[438]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[439]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[43]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[440]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[441]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[442]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[443]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[444]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[445]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[446]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[447]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[448]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[449]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[44]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[450]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[451]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[452]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[453]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[454]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[455]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[456]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[457]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[458]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[459]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[45]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[460]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[461]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[462]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[463]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[464]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[465]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[466]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[467]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[468]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[469]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[46]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[470]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[471]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[472]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[473]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[474]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[475]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[476]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[477]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[478]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[479]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[47]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[480]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[481]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[482]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[483]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[484]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[485]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[486]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[487]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[488]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[489]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[48]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[490]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[491]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[492]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[493]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[494]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[495]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[496]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[497]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[498]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[499]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[49]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[500]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[501]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[502]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[503]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[504]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[505]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[506]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[507]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[508]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[509]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[50]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[510]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[511]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[512]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[513]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[514]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[515]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[516]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[517]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[518]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[519]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[51]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[520]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[521]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[522]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[523]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[524]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[525]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[526]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[527]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[528]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[529]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[52]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[530]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[531]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[532]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[533]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[534]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[535]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[536]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[537]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[538]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[539]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[53]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[540]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[541]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[542]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[543]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[544]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[545]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[546]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[547]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[548]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[549]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[54]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[550]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[551]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[552]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[553]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[554]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[555]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[556]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[557]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[558]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[559]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[55]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[560]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[561]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[562]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[563]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[564]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[565]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[566]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[567]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[568]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[569]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[56]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[570]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[571]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[572]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[573]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[574]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[575]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[576]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[577]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[578]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[579]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[57]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[580]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[581]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[582]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[583]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[584]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[585]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[586]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[587]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[588]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[589]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[58]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[590]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[591]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[592]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[593]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[594]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[595]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[596]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[597]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[598]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[599]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[59]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[600]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[601]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[602]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[603]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[604]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[605]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[606]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[607]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[608]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[609]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[60]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[610]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[611]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[612]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[613]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[614]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[615]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[616]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[617]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[618]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[619]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[61]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[620]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[621]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[622]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[623]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[624]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[625]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[626]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[627]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[628]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[629]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[62]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[630]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[631]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[632]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[633]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[634]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[635]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[636]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[637]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[638]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[639]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[63]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[640]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[64]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[65]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[66]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[67]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[68]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[69]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[70]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[71]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[72]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[73]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[74]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[75]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[76]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[77]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[78]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[79]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[80]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[81]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[82]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[83]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[84]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[85]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[86]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[87]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[88]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[89]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[90]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[91]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[92]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[93]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[94]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[95]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[96]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[97]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[98]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[99]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 18.stp[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль (66)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: SS.SEMA.2400 - Сима-профиль — обрезан 1600 (22)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
